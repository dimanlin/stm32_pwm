# Keil uVision project pwm.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: pwm +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c
  group ::Device
    C:/Keil2/ARM/PACK/Keil/STM32F1xx_DFP/1.0.4/RTE_Driver/: DMA_STM32F10x.c GPIO_STM32F10x.c
    RTE/Device/STM32F103C8/: RTE_Device.h startup_stm32f10x_md.s system_stm32f10x.c
software components: CMSIS:CORE 3.20.0, Device:DMA 1.01.0, Device:GPIO 1.01.0, Device:Startup 1.0.0
